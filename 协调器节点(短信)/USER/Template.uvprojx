# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\EXTI;..\HARDWARE\DHT11;..\HARDWARE\LCD;..\HARDWARE\ADC;..\HARDWARE\NRF24L01;..\HARDWARE\SPI;..\HARDWARE\SIM800C;..\HARDWARE\W25QXX;..\HARDWARE\USART3;..\MALLOC;..\TEXT;..\HARDWARE\TIMER;..\FATFS\src;..\HARDWARE\SDIO;..\FATFS\exfuns;..\USMART
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_fsmc.c stm32f4xx_adc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_sdio.c stm32f4xx_dma.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXTI/: exit.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SIM800C/: sim800c.c
    ../HARDWARE/USART3/: usart3.c
    ../MALLOC/: malloc.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../TEXT/: text.c fontupd.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
  group FATFS
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/exfuns/: mycc936.c exfuns.c fattester.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
